## bsp/artinchip/drv_bare/touch/Kconfig
```kconfig
menu "Touch Panel Support"
    depends on AIC_USING_BARE_TOUCH
    source "bsp/artinchip/drv_bare/touch/gt911/Kconfig"
endmenu
```
